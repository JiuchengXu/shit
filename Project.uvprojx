# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD,
  c include: .\Libraries\CMSIS;.\Libraries\StdPeriph_Driver;.\Libraries\startup;.\Hardware;.\Main;.\uCOS\Cfg;.\uCOS\CPU;.\uCOS\LIB;.\uCOS\Ports;.\uCOS\Source;.\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Libraires
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./Libraries/StdPeriph_Driver/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./Libraries/startup/: startup_stm32f10x_hd.s
  group Main
    ./Main/: main.c stm32f10x_it.c stm32f10x_conf.h app_cfg.h includes.h bsp.c
  group Hardware
    ./Hardware/: net.h usart.c led.c esp8266.c bus.c IrDA.c string.c beep.c 38k.c adx345.c i2c.c time.c
    ./: adc.c gpio.c at24c02.c i2s.c key.c gun.c clothes.c spi_flash.c
  group uCOS
    ./uCOS/Cfg/: os_cfg.h os_cfg_app.h os_app_hooks.c
    ./uCOS/CPU/: cpu_a.asm cpu_c.c cpu_core.c
    ./uCOS/Ports/: os_cpu_a.asm os_cpu_c.c
    ./uCOS/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./uCOS/LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Application
    ./Application/: task.c
